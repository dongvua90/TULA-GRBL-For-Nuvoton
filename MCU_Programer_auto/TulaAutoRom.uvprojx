# Keil uVision project TulaAutoRom.uvprojx, settings and files
target ROM_AUTOMATIC (6190000::V6.19::ARMCLANG)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: TulaAutoRom
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC100Series\Include;..\Library\NUC1xx-LB_002\Include;..\Library\NuMakerLib\Include;..\Library\StdDriver\inc;..\MCU_Programer_auto
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ../Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group USER
    ../Library/NuMakerLib/Source/: SYS_init.c
    ./grbl/: grbl.h
    ./: General.c General.h SimEeprom.c SimEeprom.h ControlOutput.c ControlOutput.h Info.txt
  group LIB
    ../Library/StdDriver/src/: clk.c gpio.c sys.c timer.c uart.c fmc.c
  group grbl
    ./grbl/: coolant_control.c eeprom.c gcode.c jog.c limits.c main.c motion_control.c nuts_bolts.c planner.c print.c probe.c protocol.c report.c serial.c settings.c sleep.c spindle_control.c stepper.c system.c
software components: CMSIS:CORE 5.6.0
